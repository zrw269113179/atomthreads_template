<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\atomthreads-stm8l-iar.ewp</path>
  </project>
  <batchBuild/>
</workspace>


